options:
  parameters:
    author: bimbim
    generate_options: qt_gui
    id: receiver_004_fromAudio
    output_language: python
    run_options: run
    title: receiver 004 from Audio
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {state: disabled}
- name: const_definition
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: loop_bandwidth
  id: variable
  parameters:
    value: '-0.111344*np.log(baudrate) + 1.045302'
  states: {state: disabled}
- name: loop_bandwidth
  id: variable
  parameters:
    value: 2*np.pi*0.04
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: output_file_path
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: packet_size
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1'
    ntaps: 51*sps
    samp_rate: samp_rate
    sym_rate: baudrate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: const_definition
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10'
    rate: '1e-4'
    reference: 2*np.sqrt(2)
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-carrier_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_1_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: int(np.log2(len(const_definition.points())))
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_in/audio_from_another_computer.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_definition
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: len(const_definition.points())
    use_snr: 'True'
    w: 2*np.pi/100
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(const_definition.points())
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: const_definition.pre_diff_code()
  states: {state: disabled}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '3'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: const_definition
    damping: 1.0/np.sqrt(2.0)
    loop_bw: loop_bandwidth
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.4142'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import warnings
      import base64

      import numpy as np
      from gnuradio import gr
      from reedsolo import RSCodec, ReedSolomonError
      import pmt

      def decode_single_packet(packet,
                               ecc,
                               id_len,
                               data_len):
          """takes a single packet and decode it.

          Args:
              packet (bytes): input packet
              ecc (RSCodec): Reed Solomon Encoder
              id_len (int): id descriptor length
              data_len (int): data length descriptor length

          Returns:
              id, data (int, bytes): packet id, packet data
          """
          try:
              decoded_packet = ecc.decode(packet)[0]
              id = int.from_bytes(decoded_packet[:id_len], 'big') - 1
              d_len = int.from_bytes(decoded_packet[id_len:id_len + data_len], 'big')
              if id == -1: # filter out the preamble and postamble
                  if b'eof' in decoded_packet:
                      return (-1, b'eof')
                  else:
                      return (-1, decoded_packet[id_len + data_len:id_len + data_len + d_len])
              else:
                  return (id, decoded_packet[id_len + data_len:id_len + data_len + d_len])
          except ReedSolomonError as e:
              warnings.warn("packet is corrupted beyond repair !")
              print(e)
              return (-1, packet)

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self,
                       out_filename='',
                       packet_size=64,
                       ecc_size=6,
                       id_len=2,
                       data_len=1,
                       verbose=False):
              gr.basic_block.__init__(
                  self,
                  name='Packets to Binaries',
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.out_filename = out_filename
              self.packet_size = packet_size
              self.ecc = RSCodec(ecc_size)
              self.ecc.maxerrata(verbose=verbose)
              self.id_len = id_len
              self.data_len = data_len

              self.packets = {}

              self.packet_count = 0
              self.eof = False

          
          def save_file(self):
              data = dict(sorted(self.packets.items()))

              received_ids = set(data.keys())
              check_id = set(range(len(data)))
              if received_ids != check_id:
                  warnings.warn("data may be incomplete !", BytesWarning)

              data = list(data.values())
              output = b''.join(data)
              output = base64.urlsafe_b64decode(output)
              with open(self.out_filename, 'wb') as f:
                  f.write(output)

          def general_work(self, input_items, output_items):
              if not self.eof:
                  in0 = input_items[0]
                  tags = self.get_tags_in_window(0, 0, len(in0))

                  packet_start = 0
                  for tag in tags:
                      if tag.key == pmt.string_to_symbol("packet_len"):
                          packet_len = pmt.to_long(tag.value)
                          packet_end = packet_start + packet_len

                          if packet_end <= len(in0):
                              raw_packet = in0[packet_start:packet_end]

                              id, packet_data = decode_single_packet(raw_packet,
                                                                  self.ecc,
                                                                  self.id_len,
                                                                  self.data_len)
                              if len(packet_data) > 0:
                                  packet_start = packet_end
                                  self.consume(0, packet_start)
                                  if not id == -1:
                                      # saving data
                                      gr.log_debug.info(f"receiving packet {id:0>6d} : {len(packet_data)}")
                                      self.packets[id] = packet_data
                                      return 0
                                  else:
                                      # checking if it is EOF
                                      gr.log_debug.info(f"receiving packet pre/postamble : {len(packet_data)}")
                                      if b'eof' in packet_data:
                                          gr.log_debug.info("receving EOF")
                                          self.eof = True
                                          self.save_file()
                                          gr.log_debug.info(f'saving file to {self.out_filename}')
                                      return 0
                              else:
                                  gr.log_debug.info("no data in packet")
                                  return 0

                          else:
                              gr.log_debug.info("packet not complete, waiting for more data")
                              return 0              
                      else:
                          gr.log_debug.info(f'unknown tag {tag.key}')
                          return 0
              return -1 # Return -1 to indicate end of file

      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '10'
    id_len: '2'
    out_filename: output_file_path
    packet_size: packet_size
    verbose: 'False'
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_dec
    puncpat: '''11'''
    threadtype: none
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1,1,1,1]'
    label1: symbol sync
    label2: costas loops
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: '[0,1,1,1]'
    label1: raw input
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: '[0,0,2,1]'
    type: float
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', fec_extended_decoder_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_const_xx_1_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_xx_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_multiply_xx_1, '0', fft_filter_xxx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', blocks_float_to_complex_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_xx_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '1']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_1_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_1_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_probe_mpsk_snr_est_c_0, noise, digital_costas_loop_cc_0_0, noise]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
