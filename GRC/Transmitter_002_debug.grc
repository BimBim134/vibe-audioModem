options:
  parameters:
    generate_options: qt_gui
    id: transmitter_002_debug
    output_language: python
    run_options: run
    title: transmitter
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '50'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: const_definition
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_out/encodedOutput
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_out/output
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    minoutbuf: '1'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_out/clean_transmission.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const_definition
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: bytes to packets block
      """

      from random import randbytes
      import pmt
      from pathlib import Path
      import base64

      from reedsolo import RSCodec
      from gnuradio import gr
      import numpy as np


      def importFileFromPath(path):
          """import file as binary

          Args:
              path (str): file path

          Returns:
              data (bytes): output file
          """
          with open(path, 'rb') as f:
              data = f.read()
          return data


      def split_into_chuncks(data, chunck_size):
          """takes some binary data and split it into chuncks

          Args:
              data (bytes): input data
              chunck_size (int): chunck size in bytes

          Yields:
              bytes: chunck
          """
          for i in range(0, len(data), chunck_size):
              yield data[i:i + chunck_size]



      def binary_to_encoded_packet(binaryFile,
                                   packet_size=64,
                                   preamble_size = 3,
                                   postamble_size = 3,
                                   ecc_size=6,
                                   id_len=2,
                                   data_len=1,
                                   verbose=False):
          """takes a binary file and split it into encoded packets.

          each packet is formatted like so, before Reed Solomon Encoding:
          [ID, data_length, data]

          Args:
              binaryFile (bytes, str): input binary file
              packet_size (int, optional): total packet size in bytes. Defaults to 64.
              preamble_size(int, optionnal): preamble size in packet.
              postamble_size(int, optionnal): postamble size in packet.
              ecc_size (int, optional): Error Correction Code length. Defaults to 5.
              id_len (int, optional): id descriptor length. (With 2 bytes, 65535 packet can be identified at most). Defaults to 2.
              data_len (int, optional): data length descriptor length. (with 1 byte, max packet size is 255). Defaults to 1.
              verbose (bool, optional): if true, you get to know the ecc performance.
          Returns:
              output (np.uint8): output packets
          """
          if isinstance(binaryFile, str):
              path = Path(binaryFile)
              if path.is_file():
                  binaryFile = importFileFromPath(path)
              else:
                  raise FileExistsError
          elif isinstance(binaryFile, bytes):
              pass
          else:
              raise TypeError

          ecc = RSCodec(ecc_size)
          ecc.maxerrata(verbose=verbose)

          binaryFile = base64.urlsafe_b64encode(binaryFile)

          chuncks = split_into_chuncks(binaryFile,
                                       packet_size - ecc_size - id_len - data_len)
          
          preamble = [(0).to_bytes(id_len, 'big') + randbytes(packet_size - id_len - ecc_size)] * preamble_size
          postamble = [(0).to_bytes(id_len, 'big') + b'eof' + randbytes(packet_size - id_len - ecc_size -3)] * postamble_size

          chunck_with_id = [(i+1).to_bytes(id_len, 'big') + len(c).to_bytes(data_len, 'big') + c
                            for i, c in enumerate(chuncks)]

          while len(chunck_with_id[-1]) < packet_size - ecc_size:
              chunck_with_id[-1] += randbytes(1)

          # adding the preamble and postamble
          chunck_with_id = preamble + chunck_with_id + postamble

          encoded_chuncks = [ecc.encode(c) for c in chunck_with_id]

          output = [np.frombuffer(ec, dtype=np.uint8) for ec in encoded_chuncks]

          return output


      class blk(gr.basic_block):
          def __init__(self,
                       input_binary=randbytes(1000),
                       packet_size=64,
                       preamble_size=3,
                       postamble_size=3,
                       ecc_size=6,
                       id_len=2,
                       data_len=1):
              gr.sync_block.__init__(
                  self,
                  name='Binary to Packet',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.packet_size = packet_size
              self.out_packets = binary_to_encoded_packet(binaryFile=input_binary,
                                                          packet_size=packet_size,
                                                          preamble_size=preamble_size,
                                                          postamble_size=postamble_size,
                                                          ecc_size=ecc_size,
                                                          id_len=id_len,
                                                          data_len=data_len)
              self.id_len = id_len
              self.current_packet_index = 0
              self.indx = 0
              self.packet_count = len(self.out_packets)
              self.eof = False

          def work(self, input_items, output_items):
              if not self.eof:
                  if self.current_packet_index < self.packet_count:
                      current_packet = self.out_packets[self.current_packet_index]
                      current_packet_size = len(current_packet)
                      output_items[0][:current_packet_size] = current_packet
                      id = int.from_bytes(current_packet[:self.id_len], 'big') - 1

                      key = pmt.intern("packet_len")
                      val = pmt.from_long(current_packet_size)
                      self.add_item_tag(0,  # Write to output port 0
                                      self.indx,   # Index of the tag
                                      key,   # Key of the tag
                                      val,
                                      srcid=pmt.PMT_F)
                      if not id == -1:
                          gr.log_debug.info(f"sending packet {id:0>6d} : {current_packet_size} bytes")
                      else:
                          gr.log_debug.info(f"sending packet pre/postamble : {current_packet_size} bytes")
                      self.indx += current_packet_size
                      self.current_packet_index += 1
                      self.produce(0, current_packet_size)
                      return 0
                  else:
                      self.eof = True
                      gr.log_debug.info("EOF")
                      return 0
              else:
                  return 0


      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '6'
    id_len: '2'
    input_binary: '"/home/bimbim/Codes/vibe-audioModem/sampleFile.txt"'
    packet_size: '64'
    postamble_size: '3'
    preamble_size: '3'
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_enc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle2_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_0, '0', digital_protocol_formatter_bb_0, '0']
- [fec_extended_encoder_0, '0', blocks_repack_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
