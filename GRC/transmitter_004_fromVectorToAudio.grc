options:
  parameters:
    author: bimbim
    generate_options: no_gui
    id: transmitter_004_fromVectorToAudio
    output_language: python
    run_options: run
    title: transmitter 4 from vector to audio
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '128'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: const_definition
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: input_file_path
  id: variable
  parameters:
    value: '"/home/bimbim/Codes/vibe-audioModem/sampleFileLong.txt"'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '0.5'
    high_cutoff_freq: carrier_freq+baudrate
    low_cutoff_freq: carrier_freq-baudrate
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_KAISER
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: ''
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const_definition
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_enc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    label1: spectrum
    type: float
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: I signal
    label2: Q signal
    size: '2048'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [fec_extended_encoder_0, '0', blocks_repack_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
