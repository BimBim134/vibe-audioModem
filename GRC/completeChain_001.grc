options:
  parameters:
    generate_options: no_gui
    id: completeChain_001
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: bytes to packets block
      """

      from random import randbytes
      import pmt
      from pathlib import Path

      from reedsolo import RSCodec
      from gnuradio import gr
      import numpy as np


      def importFileFromPath(path):
          """import file as binary

          Args:
              path (str): file path

          Returns:
              data (bytes): output file
          """
          with open(path, 'rb') as f:
              data = f.read()
          return data


      def split_into_chuncks(data, chunck_size):
          """takes some binary data and split it into chuncks

          Args:
              data (bytes): input data
              chunck_size (int): chunck size in bytes

          Yields:
              bytes: chunck
          """
          for i in range(0, len(data), chunck_size):
              yield data[i:i + chunck_size]



      def binary_to_encoded_packet(binaryFile,
                                   packet_size=64,
                                   preamble_size = 3,
                                   postamble_size = 3,
                                   ecc_size=6,
                                   id_len=2,
                                   data_len=1,
                                   verbose=False):
          """takes a binary file and split it into encoded packets.

          each packet is formatted like so, before Reed Solomon Encoding:
          [ID, data_length, data]

          Args:
              binaryFile (bytes, str): input binary file
              packet_size (int, optional): total packet size in bytes. Defaults to 64.
              preamble_size(int, optionnal): preamble size in packet.
              postamble_size(int, optionnal): postamble size in packet.
              ecc_size (int, optional): Error Correction Code length. Defaults to 5.
              id_len (int, optional): id descriptor length. (With 2 bytes, 65535 packet can be identified at most). Defaults to 2.
              data_len (int, optional): data length descriptor length. (with 1 byte, max packet size is 255). Defaults to 1.
              verbose (bool, optional): if true, you get to know the ecc performance.
          Returns:
              output (np.uint8): output packets
          """
          if isinstance(binaryFile, str):
              path = Path(binaryFile)
              if path.is_file():
                  binaryFile = importFileFromPath(path)
              else:
                  raise FileExistsError
          elif isinstance(binaryFile, bytes):
              pass
          else:
              raise TypeError

          ecc = RSCodec(ecc_size)
          ecc.maxerrata(verbose=verbose)

          chuncks = split_into_chuncks(binaryFile,
                                       packet_size - ecc_size - id_len - data_len)
          
          preamble = [(0).to_bytes(id_len, 'big') + randbytes(packet_size - id_len)] * preamble_size
          postamble = [(0).to_bytes(id_len, 'big') + randbytes(packet_size - id_len)] * postamble_size

          chunck_with_id = preamble + [(i+1).to_bytes(id_len, 'big') +
                                       len(c).to_bytes(data_len, 'big') + c
                                       for i, c in enumerate(chuncks)] + postamble

          while len(chunck_with_id[-1]) < packet_size - ecc_size:
              chunck_with_id[-1] += randbytes(1)

          encoded_chuncks = [ecc.encode(c) for c in chunck_with_id]

          output = [np.frombuffer(ec, dtype=np.uint8) for ec in encoded_chuncks]

          return output


      class blk(gr.sync_block):
          def __init__(self,
                       input_binary=randbytes(1000),
                       packet_size=64,
                       preamble_size=3,
                       postamble_size=3,
                       ecc_size=6,
                       id_len=2,
                       data_len=1):
              gr.sync_block.__init__(
                  self,
                  name='Binary to Packet',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.packet_size = packet_size
              self.out_packets = binary_to_encoded_packet(input_binary,
                                                          preamble_size,
                                                          postamble_size,
                                                          packet_size,
                                                          ecc_size,
                                                          id_len,
                                                          data_len)
              self.current_packet_index = 0
              self.indx = 0
              self.packet_count = len(self.out_packets)
              self.eof = False

          def work(self, input_items, output_items):
              if not self.eof:
                  if self.current_packet_index <= self.packet_count:
                      output_items[0][:self.packet_size] = self.out_packets[self.current_packet_index]
                      self.current_packet_index += 1

                      packet_length = len(output_items[0])
                      key = pmt.intern("packet_len")
                      val = pmt.from_long(packet_length)
                      self.add_item_tag(0,  # Write to output port 0
                                      self.indx,   # Index of the tag
                                      key,   # Key of the tag
                                      val,
                                      srcid=pmt.PMT_F)
                      self.indx += packet_length
                      return packet_length
                  else:
                      self.eof = True
                      return 0
              else:
                  return 0


      if __name__ == "__main__":
          test = blk()
    data_len: ''
    ecc_size: ''
    id_len: ''
    input_binary: ''
    packet_size: ''
    postamble_size: ''
    preamble_size: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {}

connections:
- [epy_block_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
