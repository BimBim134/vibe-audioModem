options:
  parameters:
    generate_options: no_gui
    id: channel_simulation
    output_language: python
    run_options: run
    title: channel_simulation
  states: {}

blocks:
- name: noise_ratio
  id: variable
  parameters:
    value: '0'
  states: {}
- name: outpout_filename
  id: variable
  parameters:
    value: f"/home/bimbim/Codes/vibe-audioModem/GRC/test_out/transmission_SN{noise_ratio:.2e}wav"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-noise_ratio
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_ratio
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: outpout_filename
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_out/clean_transmission.wav
    repeat: 'False'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
