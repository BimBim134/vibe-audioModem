options:
  parameters:
    author: bimbim
    generate_options: qt_gui
    id: test_mux
    output_language: python
    title: test mux
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (10, 1)
    type: int
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: int
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: tuple([1]*100)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: int
    vector: tuple([0]*100)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
  states: {}

connections:
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_int_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
