options:
  parameters:
    author: bimbim
    generate_options: no_gui
    id: peak_detector
    output_language: python
    title: peak_detector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from scipy.signal import find_peaks

      class blk(gr.sync_block):
          """Peak Frequency Detector"""

          def __init__(self, sample_rate=48000, fft_size=1024, threshold=10):
              gr.sync_block.__init__(
                  self,
                  name='Peak Frequency Detector',
                  in_sig=[(np.float32, fft_size)],  # Accepts vector of fft_size elements
                  out_sig=None
              )
              self.sample_rate = sample_rate
              self.fft_size = fft_size
              self.threshold = threshold

          def work(self, input_items, output_items):
              for spectrum in input_items[0]:  # Iterate over vector batches
                  freqs = np.fft.rfftfreq(self.fft_size, 1.0 / self.sample_rate)

                  # Find all local peaks above threshold
                  peaks, props = find_peaks(spectrum, height=self.threshold)

                  if peaks.size > 0:
                      max_peak_idx = peaks[np.argmax(props['peak_heights'])]
                      peak_freq = freqs[max_peak_idx]
                      print(f"Detected Peak Frequency: {peak_freq:.2f} Hz")
                  else:
                      print("No peak detected above threshold.")
              
              return len(input_items[0])
    fft_size: '1024'
    sample_rate: samp_rate
    threshold: '10'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}

connections:
- [audio_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
