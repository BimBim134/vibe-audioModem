options:
  parameters:
    description: TED gain estimation
    generate_options: qt_gui
    id: completeChain_005
    output_language: python
    thread_safe_setters: '1'
    title: complete chain 5
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '128'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: const_definition
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: decim_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frequency_offset
  id: variable
  parameters:
    value: '20'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: loop_bandwidth
  id: variable
  parameters:
    value: '0.045'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '128'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baudrate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: sps_post_sync
  id: variable
  parameters:
    value: '10'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: const_definition
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10'
    rate: '1e-4'
    reference: np.sqrt(2)
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: np.sqrt(2)
    freq: '-carrier_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_1_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: int(np.log2(len(const_definition.points())))
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/GRC/test_in/audio_from_another_computer.wav
    repeat: 'True'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1+frequency_offset/carrier_freq
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_definition
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const_definition
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
    truncate: 'True'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: len(const_definition.points())
    use_snr: 'True'
    w: 2*np.pi/200
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(const_definition.points())
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11*sps
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: '1e-5'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps_post_sync
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: const_definition.pre_diff_code()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: const_definition
    damping: '2'
    loop_bw: loop_bandwidth
    max_dev: '1.2'
    nfilters: nfilts
    osps: sps_post_sync
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps/decim_factor
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: bytes to packets block
      """

      from random import randbytes
      import pmt
      from pathlib import Path
      import base64

      from reedsolo import RSCodec
      from gnuradio import gr
      import numpy as np


      def importFileFromPath(path):
          """import file as binary

          Args:
              path (str): file path

          Returns:
              data (bytes): output file
          """
          with open(path, 'rb') as f:
              data = f.read()
          return data


      def split_into_chuncks(data, chunck_size):
          """takes some binary data and split it into chuncks

          Args:
              data (bytes): input data
              chunck_size (int): chunck size in bytes

          Yields:
              bytes: chunck
          """
          for i in range(0, len(data), chunck_size):
              yield data[i:i + chunck_size]



      def binary_to_encoded_packet(binaryFile,
                                   packet_size=64,
                                   preamble_size = 3,
                                   postamble_size = 3,
                                   ecc_size=6,
                                   id_len=2,
                                   data_len=1,
                                   verbose=False):
          """takes a binary file and split it into encoded packets.

          each packet is formatted like so, before Reed Solomon Encoding:
          [ID, data_length, data]

          Args:
              binaryFile (bytes, str): input binary file
              packet_size (int, optional): total packet size in bytes. Defaults to 64.
              preamble_size(int, optionnal): preamble size in packet.
              postamble_size(int, optionnal): postamble size in packet.
              ecc_size (int, optional): Error Correction Code length. Defaults to 5.
              id_len (int, optional): id descriptor length. (With 2 bytes, 65535 packet can be identified at most). Defaults to 2.
              data_len (int, optional): data length descriptor length. (with 1 byte, max packet size is 255). Defaults to 1.
              verbose (bool, optional): if true, you get to know the ecc performance.
          Returns:
              output (np.uint8): output packets
          """
          if isinstance(binaryFile, str):
              path = Path(binaryFile)
              if path.is_file():
                  binaryFile = importFileFromPath(path)
              else:
                  raise FileExistsError
          elif isinstance(binaryFile, bytes):
              pass
          else:
              raise TypeError

          ecc = RSCodec(ecc_size)
          ecc.maxerrata(verbose=verbose)

          binaryFile = base64.urlsafe_b64encode(binaryFile)

          chuncks = split_into_chuncks(binaryFile,
                                       packet_size - ecc_size - id_len - data_len)
          
          preamble = [(0).to_bytes(id_len, 'big') + randbytes(packet_size - id_len - ecc_size)] * preamble_size
          postamble = [(0).to_bytes(id_len, 'big') + b'eof' + randbytes(packet_size - id_len - ecc_size -3)] * postamble_size

          chunck_with_id = [(i+1).to_bytes(id_len, 'big') + len(c).to_bytes(data_len, 'big') + c
                            for i, c in enumerate(chuncks)]

          while len(chunck_with_id[-1]) < packet_size - ecc_size:
              chunck_with_id[-1] += randbytes(1)

          # adding the preamble and postamble
          chunck_with_id = preamble + chunck_with_id + postamble

          encoded_chuncks = [ecc.encode(c) for c in chunck_with_id]

          output = [np.frombuffer(ec, dtype=np.uint8) for ec in encoded_chuncks]

          return output


      class blk(gr.basic_block):
          def __init__(self,
                       input_binary=randbytes(1000),
                       packet_size=64,
                       preamble_size=3,
                       postamble_size=3,
                       ecc_size=6,
                       id_len=2,
                       data_len=1):
              gr.basic_block.__init__(
                  self,
                  name='Binary to Packet',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.packet_size = packet_size
              self.out_packets = binary_to_encoded_packet(binaryFile=input_binary,
                                                          packet_size=packet_size,
                                                          preamble_size=preamble_size,
                                                          postamble_size=postamble_size,
                                                          ecc_size=ecc_size,
                                                          id_len=id_len,
                                                          data_len=data_len)
              self.preamble_size = preamble_size
              self.postamble_size = postamble_size

              self.id_len = id_len
              self.current_packet_index = 0
              self.indx = 0
              self.packet_count = len(self.out_packets)
              self.eof = False

          def get_state(self, idx):
              if idx < self.preamble_size:
                  return "preamble"
              elif self.preamble_size <= idx < self.packet_count - self.postamble_size:
                  return "data"
              elif self.packet_count - self.postamble_size <= idx < self.packet_count:
                  return "postamble"
              else:
                  return "idle"

          def general_work(self, input_items, output_items):
              if not self.eof:
                  if self.current_packet_index < self.packet_count:
                      current_packet = self.out_packets[self.current_packet_index]
                      output_items[0][:self.packet_size] = current_packet
                      gr.log_debug.info(f"sending packet {self.current_packet_index}. {self.get_state(self.current_packet_index)}")

                      self.indx += self.packet_size
                      self.current_packet_index += 1
                      self.produce(0, self.packet_size)
                      return 0
                  else:
                      self.eof = True
                      gr.log_debug.info("EOF")
                      return 0
              else:
                  return 0


      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '10'
    id_len: '2'
    input_binary: '"/home/bimbim/Codes/vibe-audioModem/sampleFileShort.txt"'
    packet_size: packet_size
    postamble_size: '6'
    preamble_size: '3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import warnings
      import base64

      import numpy as np
      from gnuradio import gr
      from reedsolo import RSCodec, ReedSolomonError
      import pmt

      def decode_single_packet(packet,
                               ecc,
                               id_len,
                               data_len):
          """takes a single packet and decode it.

          Args:
              packet (bytes): input packet
              ecc (RSCodec): Reed Solomon Encoder
              id_len (int): id descriptor length
              data_len (int): data length descriptor length

          Returns:
              id, data (int, bytes): packet id, packet data
          """
          try:
              decoded_packet = ecc.decode(packet)[0]
              id = int.from_bytes(decoded_packet[:id_len], 'big') - 1
              d_len = int.from_bytes(decoded_packet[id_len:id_len + data_len], 'big')
              if id == -1: # filter out the preamble and postamble
                  if b'eof' in decoded_packet:
                      return (-1, b'eof')
                  else:
                      return (-1, decoded_packet[id_len + data_len:id_len + data_len + d_len])
              else:
                  return (id, decoded_packet[id_len + data_len:id_len + data_len + d_len])
          except ReedSolomonError as e:
              warnings.warn("packet is corrupted beyond repair !")
              print(e)
              return (-1, packet)

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self,
                       out_filename='',
                       packet_size=64,
                       ecc_size=6,
                       id_len=2,
                       data_len=1,
                       verbose=False):
              gr.basic_block.__init__(
                  self,
                  name='Packets to Binaries',
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.out_filename = out_filename
              self.packet_size = packet_size
              self.ecc = RSCodec(ecc_size)
              self.ecc.maxerrata(verbose=verbose)
              self.id_len = id_len
              self.data_len = data_len

              self.packets = {}

              self.packet_count = 0
              self.eof = False

          
          def save_file(self):
              data = dict(sorted(self.packets.items()))

              received_ids = set(data.keys())
              check_id = set(range(len(data)))
              if received_ids != check_id:
                  warnings.warn("data may be incomplete !", BytesWarning)

              data = list(data.values())
              output = b''.join(data)
              output = base64.urlsafe_b64decode(output)
              with open(self.out_filename, 'wb') as f:
                  f.write(output)

          def general_work(self, input_items, output_items):
              if not self.eof:
                  in0 = input_items[0]
                  tags = self.get_tags_in_window(0, 0, len(in0))

                  packet_start = 0
                  for tag in tags:
                      if tag.key == pmt.string_to_symbol("packet_len"):
                          packet_len = pmt.to_long(tag.value)
                          packet_end = packet_start + packet_len

                          if packet_end <= len(in0):
                              raw_packet = in0[packet_start:packet_end]

                              id, packet_data = decode_single_packet(raw_packet,
                                                                  self.ecc,
                                                                  self.id_len,
                                                                  self.data_len)
                              if len(packet_data) > 0:
                                  packet_start = packet_end
                                  self.consume(0, packet_start)
                                  if not id == -1:
                                      # saving data
                                      gr.log_debug.info(f"receiving packet {id:0>6d} : {len(packet_data)}")
                                      self.packets[id] = packet_data
                                      return 0
                                  else:
                                      # checking if it is EOF
                                      gr.log_debug.info(f"receiving packet pre/postamble : {len(packet_data)}")
                                      if b'eof' in packet_data:
                                          gr.log_debug.info("receving EOF")
                                          self.eof = True
                                          self.save_file()
                                          gr.log_debug.info(f'saving file to {self.out_filename}')
                                      return 0
                              else:
                                  gr.log_debug.info("no data in packet")
                                  return 0

                          else:
                              gr.log_debug.info("packet not complete, waiting for more data")
                              return 0              
                      else:
                          gr.log_debug.info(f'unknown tag {tag.key}')
                          return 0
              return -1 # Return -1 to indicate end of file

      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '10'
    id_len: '2'
    out_filename: '"/home/bimbim/Codes/vibe-audioModem/GRC/test_out/test_decoded.txt"'
    packet_size: packet_size
    verbose: 'False'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_dec
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_enc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: decim_factor
    taps: rrc_taps
    type: ccf
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '64'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '64'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    size: '64'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    norm_window: 'True'
    type: float
    ymax: '0'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[0,0,1,1]'
    name: freq
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[0,1,1,1]'
    name: phase
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[0,2,1,1]'
    name: eerror
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1,0,1,2]'
    label1: error
    name: symbol sync analysis
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: '[1,2,1,1]'
    name: symbol timing
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: noisy_audio_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio_signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: noisy_audio_signal
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: audio_signal
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0_0_0, '0', fec_extended_decoder_0, '0']
- [blocks_complex_to_real_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_real_1, '0', blocks_throttle2_1, '0']
- [blocks_float_to_complex_0_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_xx_1_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_1, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle2_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_1, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_xx_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_1, '0']
- [channels_channel_model_0, '0', blocks_complex_to_real_1, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_1_0, '0']
- [digital_fll_band_edge_cc_0, '0', fft_filter_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '1', qtgui_time_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '2', qtgui_time_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '3', qtgui_time_sink_x_0_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_2, '0']
- [digital_map_bb_1_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_2, '1']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [fec_extended_encoder_0, '0', blocks_repack_bits_bb_1_0, '0']
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0_0, '0']
- [virtual_source_0_0, '0', hilbert_fc_0, '0']
- [virtual_source_0_1, '0', blocks_throttle2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
