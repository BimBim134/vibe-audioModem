options:
  parameters:
    author: bimbim
    generate_options: no_gui
    id: receiver_master
    output_language: python
    run_options: run
    title: receiver master
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: const_definition
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: 100/samp_rate
  states: {}
- name: output_file_path
  id: variable
  parameters:
    value: '""'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10'
    rate: '1e-4'
    reference: 2*np.sqrt(2)
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-carrier_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_1_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: int(np.log2(len(const_definition.points())))
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: const_definition
    fmax: freq_deviation
    fmin: '-freq_deviation'
    loop_bw: '0.06'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_dec
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    timeout: '100'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', fec_extended_decoder_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_const_xx_1_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_xx_1, '0', digital_constellation_receiver_cb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_xx_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
