options:
  parameters:
    author: bimbim
    generate_options: qt_gui
    id: receiver_master
    output_language: python
    run_options: run
    title: receiver master
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[79,109]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: const_definition
  id: variable_constellation
  parameters:
    npwr: '0'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {state: disabled}
- name: const_definition
  id: variable
  parameters:
    value: digital.psk_constellation(m=4, mod_code=digital.mod_codes.GRAY_CODE, differential=True)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(sps/4)
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: 100/samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baudrate)
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: const_definition
    step_size: '.01'
    type: lms
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10'
    rate: '1e-4'
    reference: np.sqrt(2)
    type: complex
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:0,0
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: int(np.log2(len(const_definition.points())))
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bimbim/Codes/vibe-audioModem/research/test_default_const_default_pkt_default_sig_default.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: const_definition
    fmax: freq_deviation
    fmin: '-freq_deviation'
    loop_bw: '0.06'
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: int(decimation/4)
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: const_definition
    damping: 1/np.sqrt(2)
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: int(decimation/4)
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps/decimation
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_dec
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), 10)
    type: ccc
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    size: '128'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2_0
  id: qtgui_const_sink_x
  parameters:
    size: '128'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: '"tcp://*:5555"'
    timeout: '100'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', fec_extended_decoder_0, '0']
- [blocks_multiply_const_xx_1_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_xx_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_wavfile_source_0, '0', hilbert_fc_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0_2, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_2_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [fec_extended_decoder_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
