options:
  parameters:
    generate_options: no_gui
    id: completeChain_003
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: enc_tpc
  id: variable_tpc_encoder_def
  parameters:
    bval: '0'
    col_poly: '[123]'
    kcol: '40'
    krow: '72'
    ndim: '0'
    qval: '4'
    row_poly: '[123]'
  states: {}
- name: packet_size
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_tpc_decoder_def_0
  id: variable_tpc_decoder_def
  parameters:
    bval: '0'
    col_poly: '[123]'
    decoder_type: '0'
    kcol: '40'
    krow: '72'
    max_iter: '6'
    ndim: '0'
    qval: '4'
    row_poly: '[123]'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: bytes to packets block
      """

      from random import randbytes
      import pmt
      from pathlib import Path
      import base64

      from reedsolo import RSCodec
      from gnuradio import gr
      import numpy as np


      def importFileFromPath(path):
          """import file as binary

          Args:
              path (str): file path

          Returns:
              data (bytes): output file
          """
          with open(path, 'rb') as f:
              data = f.read()
          return data


      def split_into_chuncks(data, chunck_size):
          """takes some binary data and split it into chuncks

          Args:
              data (bytes): input data
              chunck_size (int): chunck size in bytes

          Yields:
              bytes: chunck
          """
          for i in range(0, len(data), chunck_size):
              yield data[i:i + chunck_size]



      def binary_to_encoded_packet(binaryFile,
                                   packet_size=64,
                                   preamble_size = 3,
                                   postamble_size = 3,
                                   ecc_size=6,
                                   id_len=2,
                                   data_len=1,
                                   verbose=False):
          """takes a binary file and split it into encoded packets.

          each packet is formatted like so, before Reed Solomon Encoding:
          [ID, data_length, data]

          Args:
              binaryFile (bytes, str): input binary file
              packet_size (int, optional): total packet size in bytes. Defaults to 64.
              preamble_size(int, optionnal): preamble size in packet.
              postamble_size(int, optionnal): postamble size in packet.
              ecc_size (int, optional): Error Correction Code length. Defaults to 5.
              id_len (int, optional): id descriptor length. (With 2 bytes, 65535 packet can be identified at most). Defaults to 2.
              data_len (int, optional): data length descriptor length. (with 1 byte, max packet size is 255). Defaults to 1.
              verbose (bool, optional): if true, you get to know the ecc performance.
          Returns:
              output (np.uint8): output packets
          """
          if isinstance(binaryFile, str):
              path = Path(binaryFile)
              if path.is_file():
                  binaryFile = importFileFromPath(path)
              else:
                  raise FileExistsError
          elif isinstance(binaryFile, bytes):
              pass
          else:
              raise TypeError

          ecc = RSCodec(ecc_size)
          ecc.maxerrata(verbose=verbose)

          binaryFile = base64.urlsafe_b64encode(binaryFile)

          chuncks = split_into_chuncks(binaryFile,
                                       packet_size - ecc_size - id_len - data_len)
          
          preamble = [(0).to_bytes(id_len, 'big') + randbytes(packet_size - id_len - ecc_size)] * preamble_size
          postamble = [(0).to_bytes(id_len, 'big') + b'eof' + randbytes(packet_size - id_len - ecc_size -3)] * postamble_size

          chunck_with_id = [(i+1).to_bytes(id_len, 'big') + len(c).to_bytes(data_len, 'big') + c
                            for i, c in enumerate(chuncks)]

          while len(chunck_with_id[-1]) < packet_size - ecc_size:
              chunck_with_id[-1] += randbytes(1)

          # adding the preamble and postamble
          chunck_with_id = preamble + chunck_with_id + postamble

          encoded_chuncks = [ecc.encode(c) for c in chunck_with_id]

          output = [np.frombuffer(ec, dtype=np.uint8) for ec in encoded_chuncks]

          return output


      class blk(gr.basic_block):
          def __init__(self,
                       input_binary=randbytes(1000),
                       packet_size=64,
                       preamble_size=3,
                       postamble_size=3,
                       ecc_size=6,
                       id_len=2,
                       data_len=1):
              gr.sync_block.__init__(
                  self,
                  name='Binary to Packet',
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.packet_size = packet_size
              self.out_packets = binary_to_encoded_packet(binaryFile=input_binary,
                                                          packet_size=packet_size,
                                                          preamble_size=preamble_size,
                                                          postamble_size=postamble_size,
                                                          ecc_size=ecc_size,
                                                          id_len=id_len,
                                                          data_len=data_len)
              self.id_len = id_len
              self.current_packet_index = 0
              self.indx = 0
              self.packet_count = len(self.out_packets)
              self.eof = False

          def work(self, input_items, output_items):
              if not self.eof:
                  if self.current_packet_index < self.packet_count:
                      current_packet = self.out_packets[self.current_packet_index]
                      current_packet_size = len(current_packet)
                      output_items[0][:current_packet_size] = current_packet
                      id = int.from_bytes(current_packet[:self.id_len], 'big') - 1

                      key = pmt.intern("packet_len")
                      val = pmt.from_long(current_packet_size)
                      self.add_item_tag(0,  # Write to output port 0
                                      self.indx,   # Index of the tag
                                      key,   # Key of the tag
                                      val,
                                      srcid=pmt.PMT_F)
                      if not id == -1:
                          gr.log_debug.info(f"sending packet {id:0>6d} : {current_packet_size} bytes")
                      else:
                          gr.log_debug.info(f"sending packet pre/postamble : {current_packet_size} bytes")
                      self.indx += current_packet_size
                      self.current_packet_index += 1
                      self.produce(0, current_packet_size)
                      return 0
                  else:
                      self.eof = True
                      gr.log_debug.info("EOF")
                      return 0
              else:
                  return 0


      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '2'
    id_len: '2'
    input_binary: '"/home/bimbim/Codes/vibe-audioModem/sampleFile.txt"'
    packet_size: '18'
    postamble_size: '3'
    preamble_size: '3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import warnings
      import base64

      import numpy as np
      from gnuradio import gr
      from reedsolo import RSCodec, ReedSolomonError
      import pmt

      def decode_single_packet(packet,
                               ecc,
                               id_len,
                               data_len):
          """takes a single packet and decode it.

          Args:
              packet (bytes): input packet
              ecc (RSCodec): Reed Solomon Encoder
              id_len (int): id descriptor length
              data_len (int): data length descriptor length

          Returns:
              id, data (int, bytes): packet id, packet data
          """
          try:
              decoded_packet = ecc.decode(packet)[0]
              id = int.from_bytes(decoded_packet[:id_len], 'big') - 1
              d_len = int.from_bytes(decoded_packet[id_len:id_len + data_len], 'big')
              if id == -1: # filter out the preamble and postamble
                  if b'eof' in decoded_packet:
                      return (-1, b'eof')
                  else:
                      return (-1, decoded_packet[id_len + data_len:id_len + data_len + d_len])
              else:
                  return (id, decoded_packet[id_len + data_len:id_len + data_len + d_len])
          except ReedSolomonError as e:
              warnings.warn("packet is corrupted beyond repair !")
              print(e)
              return (-1, packet)

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self,
                       out_filename='',
                       packet_size=64,
                       ecc_size=6,
                       id_len=2,
                       data_len=1,
                       verbose=False):
              gr.sync_block.__init__(
                  self,
                  name='Packets to Binaries',
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.out_filename = out_filename
              self.packet_size = packet_size
              self.ecc = RSCodec(ecc_size)
              self.ecc.maxerrata(verbose=verbose)
              self.id_len = id_len
              self.data_len = data_len

              self.packets = {}

              self.packet_count = 0
              self.eof = False

          
          def save_file(self):
              data = dict(sorted(self.packets.items()))

              received_ids = set(data.keys())
              check_id = set(range(len(data)))
              if received_ids != check_id:
                  warnings.warn("data may be incomplete !", BytesWarning)

              data = list(data.values())
              output = b''.join(data)
              output = base64.urlsafe_b64decode(output)
              with open(self.out_filename, 'wb') as f:
                  f.write(output)

          def work(self, input_items, output_items):
              if not self.eof:
                  in0 = input_items[0]
                  tags = self.get_tags_in_window(0, 0, len(in0))

                  packet_start = 0
                  for tag in tags:
                      if tag.key == pmt.string_to_symbol("packet_len"):
                          packet_len = pmt.to_long(tag.value)
                          packet_end = packet_start + packet_len

                          if packet_end <= len(in0):
                              raw_packet = in0[packet_start:packet_end]

                              id, packet_data = decode_single_packet(raw_packet,
                                                                  self.ecc,
                                                                  self.id_len,
                                                                  self.data_len)
                              if len(packet_data) > 0:
                                  packet_start = packet_end
                                  self.consume(0, packet_start)
                                  if not id == -1:
                                      # saving data
                                      gr.log_debug.info(f"receiving packet {id:0>6d} : {len(packet_data)}")
                                      self.packets[id] = packet_data
                                      return 0
                                  else:
                                      # checking if it is EOF
                                      gr.log_debug.info(f"receiving packet pre/postamble : {len(packet_data)}")
                                      if b'eof' in packet_data:
                                          gr.log_debug.info("receving EOF")
                                          self.eof = True
                                          self.save_file()
                                          gr.log_debug.info(f'saving file to {self.out_filename}')
                                      return 0
                              else:
                                  gr.log_debug.info("no data in packet")
                                  return 0

                          else:
                              gr.log_debug.info("packet not complete, waiting for more data")
                              return 0              
                      else:
                          gr.log_debug.info(f'unknown tag {tag.key}')
                          return 0
              return 0

      if __name__ == "__main__":
          test = blk()
    data_len: '1'
    ecc_size: '2'
    id_len: '2'
    out_filename: '"/home/bimbim/Codes/vibe-audioModem/GRC/test_out/test_turboCodes.txt"'
    packet_size: packet_size
    verbose: 'False'
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: enc_tpc
    lentagname: '"packet_len"'
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: fec_tagged_decoder_0
  id: fec_tagged_decoder
  parameters:
    decoder: variable_tpc_decoder_def_0
    lentagname: '"packet_len"'
    mtu: '1500'
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', fec_extended_tagged_encoder_0, '0']
- [blocks_throttle2_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [fec_extended_tagged_encoder_0, '0', fec_tagged_decoder_0, '0']
- [fec_tagged_decoder_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
